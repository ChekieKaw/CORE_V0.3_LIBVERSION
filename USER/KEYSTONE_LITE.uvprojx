# Keil uVision project KEYSTONE_LITE.uvprojx, settings and files
target KEYSTONE_LITE (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: KEYSTONE_LITE +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\SCR;..\DRIVER;..\HitLink
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_iwdg.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_flash.c
  group SCR
    ../SCR/: System_Init.c Interface_Init.c Schedule_Init.c delay.c Security.c sequence_sa_major.c sequence_sa_minor.c config.c com_pid_ahrs.lib
  group DRIVER
    ../DRIVER/: driver_ICM20689.c driver_MS5611.c
  group HitLink
    ../HitLink/: checksum.h hitlink.h hitlink_attitute.h hitlink_heartbeat.h protocol.h
